Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2023-03-07T10:34:47
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Mar 07 10:34:47 2023 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\3c901732-16e2-44d7-9e47-e913819eff5e\e94e5e26-44c4-45f8-a1e4-0d6aae641361\ifc * Database version: 5507 * Database creation date: Tue Mar 07 10:34:46 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Mar 07 10:34:47 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Mar 07 10:34:47 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 10558800_USA_DA399-7_EDST:28399750_USA_10558800_DA399-7_EDST, (2)
In: Default
Type - Material: z_Miele_Connection_Electric, z_Miele_Connection_ExhaustAir, z_Miele_Design_CLST, z_Miele_Design_Glass, Aluminum, z_Miele_Design_Steel_Chrom
Type - Pset_BuildingElementProxyCommon - Reference: 28399750_USA_10558800_DA399-7_EDST
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 28399750_USA_10558800_DA399-7_EDST
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Width: 898 mm; Height: 120 mm; Depth: 520 mm
